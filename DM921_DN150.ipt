# Autodesk Inventor part: DM921_DN150
## iProperties
Created: 2011-01
Part Number: DM921_DN150
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
